options:
  parameters:
    generate_options: qt_gui
    id: amine
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: variable_channel
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0.005'
  states: {}
- name: analog_random_uniform_source_x_0_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters:
    log_level: trace
  states: {}
- name: blocks_message_debug_0_0_0_0
  id: blocks_message_debug
  parameters:
    log_level: trace
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("0")
    period: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      # Implementation of a channel monitor block in GNU Radio with Python
      # This script creates a block to determine if the channel is free for communication.

      from gnuradio import gr
      import numpy as np

      class ChannelMonitor(gr.sync_block):
          def __init__(self, frequency_mhz=0, bandwidth_hz=3000, sample_rate=32000, threshold=0.1):
              """
              Initialize the Channel Monitor block.
              :param frequency_mhz: Center frequency in MHz to monitor for energy detection.
              :param bandwidth_hz: Bandwidth in Hz to average energy over.
              :param sample_rate: Sampling rate of the input signal.
              :param threshold: Energy threshold to determine if the channel is busy.
              """
              gr.sync_block.__init__(
                  self,
                  name="ChannelMonitor",  # Name of the block
                  in_sig=[np.complex64],  # Raw signal input for FFT
                  out_sig=[np.float32]    # Output signal indicating if the channel is free (1) or busy (0)
              )

              self.frequency_mhz = frequency_mhz
              self.bandwidth_hz = bandwidth_hz
              self.sample_rate = sample_rate
              self.threshold = threshold

          def work(self, input_items, output_items):
              """
              Analyze the input signal to determine if the channel is free.
              :param input_items: Samples for FFT-based channel sensing.
              :param output_items: Output indicating if the channel is free (1) or busy (0).
              """
              input_signal = input_items[0]
              output_signal = output_items[0]

              # Validate input length
              if len(input_signal) == 0:
                  raise ValueError("Input signal is empty!")

              # Compute the FFT and magnitude
              fft_size = len(input_signal)  # Use the length of the input signal
              energy = np.abs(np.fft.fft(input_signal))
              freqs = np.fft.fftfreq(fft_size, d=1 / self.sample_rate)

              # Calculate the bin index for the target frequency and bandwidth
              center_frequency_hz = self.frequency_mhz * 1e6
              if not (0 <= center_frequency_hz <= self.sample_rate / 2):
                  raise ValueError(f"Frequency {self.frequency_mhz} MHz is out of range for the sample rate {self.sample_rate} Hz")

              half_bandwidth_bins = int((self.bandwidth_hz / 2) / (self.sample_rate / fft_size))
              center_bin = int((center_frequency_hz / self.sample_rate) * fft_size)

              # Ensure center_bin is within bounds
              if center_bin >= fft_size:
                  center_bin = fft_size - 1

              # Determine the range of bins to average over
              start_bin = max(center_bin - half_bandwidth_bins, 0)
              end_bin = min(center_bin + half_bandwidth_bins, fft_size - 1)

              # Compute the average energy in the specified bandwidth
              avg_energy = np.mean(energy[start_bin:end_bin + 1])

              # Determine if the channel is free
              if avg_energy < self.threshold:
                  #print(f"[ChannelMonitor] Channel at {self.frequency_mhz} MHz (±{self.bandwidth_hz/2} Hz) is FREE. Average Energy: {avg_energy}")
                  output_signal[:] = 1.0  # Channel is free
              else:
                  #print(f"[ChannelMonitor] Channel at {self.frequency_mhz} MHz (±{self.bandwidth_hz/2} Hz) is BUSY. Average Energy: {avg_energy}")
                  output_signal[:] = 0.0  # Channel is busy

              return len(output_signal)
    bandwidth_hz: '3000'
    frequency_mhz: variable_channel
    sample_rate: samp_rate
    threshold: '2'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import struct
      import time
      import random
      import pmt
      import json
      from queue import Queue
      from gnuradio import gr

      def build_frame(src_mac, dst_mac, priority, data):
          """
          Construit la trame MAC :
            - src_mac: 6 octets
            - dst_mac: 6 octets
            - priority: 1 octet (0 ou 1)
            - length: 2 octets (taille des données)
            - data: N octets
          """
          # s = string (bytes), B = unsigned char, H = unsigned short
          length = len(data)
          fmt_header = "!IIBH"  # ! = réseau (big-endian)
          header = struct.pack(fmt_header, src_mac, dst_mac, priority, length)
          print(header)
          return header + data

      def parse_frame(frame_bytes):
          """
          Décode une trame MAC.
          Retourne (src_mac, dst_mac, priority, data).
          """
          fmt_header = "!IIBH"
          header_size = struct.calcsize(fmt_header)
          header = frame_bytes[:header_size]
          data = frame_bytes[header_size:]

          src_mac, dst_mac, priority, length = struct.unpack(fmt_header, header)
          payload = data[:length]
          return src_mac, dst_mac, priority, payload

      class csma_ca_mac_block(gr.basic_block):
          """
          Bloc CSMA/CA avec backoff exponentiel et priorités pour GNU Radio.
          """
          def __init__(self, 
                       mac_addr=1,   # MAC de ce noeud
                       cw_min_low=8,
                       cw_min_high=4,
                       cw_max=64,
                       ack_timeout=0.05,  # en secondes
                       max_retries=3):
              gr.basic_block.__init__(
                  self,
                  name="csma_ca_mac_block",
                  in_sig=None,
                  out_sig=None
              )
              
              # Adresse MAC de ce noeud
              self.mac_addr = mac_addr
              
              # Paramètres
              self.cw_min_low = cw_min_low
              self.cw_min_high = cw_min_high
              self.cw_max = cw_max
              self.ack_timeout = ack_timeout
              self.max_retries = max_retries
              
              # État interne
              self.state = "IDLE"
              self.current_frame = None
              self.current_priority = 0
              self.cw = cw_min_low
              self.retries = 0
              
              # File d'attente des paquets à transmettre
              self.tx_queue = Queue() 
              
              # Canal occupé ?
              self.channel_busy = False
              
              # Timer pour le backoff
              self.backoff_remaining = 0
              self.last_time = time.time()
              
              # Ports de messages
              self.message_port_register_in(pmt.intern("app_in"))
              self.message_port_register_in(pmt.intern("phy_in"))
              self.message_port_register_in(pmt.intern("cs_in"))  # Carrier Sense input
              self.message_port_register_out(pmt.intern("phy_out"))
              self.message_port_register_out(pmt.intern("app_out"))

              # Pour la clock de work
              self.message_port_register_in(pmt.intern("clock"))
              self.set_msg_handler(pmt.intern("clock"), self.general_work)
              
              self.set_msg_handler(pmt.intern("app_in"), self.handle_msg_in)
              self.set_msg_handler(pmt.intern("phy_in"), self.handle_phy_in)
              self.set_msg_handler(pmt.intern("cs_in"), self.handle_cs_in)

          def handle_msg_in(self, msg_pmt):
              """
              Handler pour une nouvelle trame à émettre depuis la couche application
              """
              try:
                  # Extraire les données du message PMT
                  if pmt.is_pair(msg_pmt):
                      msg_str = pmt.to_python(pmt.cdr(msg_pmt))
                      msg_dict = json.loads(msg_str)
                      if isinstance(msg_dict, dict):
                          dst_mac = msg_dict.get("dst_mac")
                          priority = msg_dict.get("priority")
                          data = msg_dict.get("data")
                          
                          # Construire la trame MAC
                          #frame = build_frame(self.mac_addr, dst_mac, priority, data)
                          
                          # Mettre en file d'attente
                          self.tx_queue.put((msg_str, priority))
                          
                          # Si on est IDLE, traiter immédiatement
                          if self.state == "IDLE":
                              self.process_next_packet()
              except Exception as e:
                  print(f"Error in handle_msg_in: {e}")
          
          def handle_new_frame(self, frame, priority):
              """
              Démarre la procédure de transmission pour une nouvelle trame
              """
              if self.state == "IDLE":
                  self.current_frame = frame
                  self.current_priority = priority
                  self.retries = 0
                  # Définir la CW initiale selon la priorité
                  if priority == 1:
                      self.cw = self.cw_min_high
                  else:
                      self.cw = self.cw_min_low
                  # Passer en BACKOFF
                  self.state = "BACKOFF"
                  self.start_backoff()
          
          def start_backoff(self):
              """
              Démarre la procédure de backoff de manière asynchrone
              """
              # Déterminer le backoff en slots
              slots = random.randint(0, self.cw - 1)
              self.backoff_remaining = slots * 0.001  # 1ms par slot
              self.last_time = time.time()
          
          def tx_frame(self):
              """
              Transmet une trame via le port PHY
              """
              try:
                  # Créer un vecteur PMT pour la trame
                  #blob = pmt.make_u8vector(len(self.current_frame), 0)
                  #for i, b in enumerate(self.current_frame):
                      #pmt.u8vector_set(blob, i, b)
                  
                  # Envoyer la trame
                  self.message_port_pub(
                      pmt.intern("phy_out"),
                      pmt.cons(pmt.intern("frame"), pmt.to_pmt(self.current_frame))#pmt.cons(pmt.intern("frame"), blob)
                  )
                  
                  # Passer en attente d'ACK
                  self.state = "WAIT_ACK"
                  self.wait_ack_start_time = time.time()
                  
              except Exception as e:
                  print(f"Error in tx_frame: {e}")
                  self.state = "IDLE"
                  self.process_next_packet()
          
          def handle_phy_in(self, msg_pmt):
              """
              Réception d'une trame depuis la PHY
              """
              try:
                  if pmt.is_pair(msg_pmt):
                      blob = pmt.cdr(msg_pmt)
                      if pmt.is_u8vector(blob):
                          # Convertir le PMT en bytes
                          frame_bytes = bytes(pmt.u8vector_elements(blob))
                          
                          # Parser la trame
                          src_mac, dst_mac, priority, payload = parse_frame(frame_bytes)
                          
                          # Vérifier si c'est un ACK pour nous
                          if payload == b'ACK' and dst_mac == self.mac_addr:
                              self.handle_rx_ack(src_mac)
                          elif dst_mac == self.mac_addr or dst_mac == b'\xFF\xFF\xFF\xFF\xFF\xFF':
                              # Trame de données pour nous ou broadcast
                              # Remonter à la couche application
                              msg_dict = {
                                  "src_mac": src_mac,
                                  "priority": priority,
                                  "data": payload
                              }
                              self.message_port_pub(
                                  pmt.intern("app_out"),
                                  pmt.cons(pmt.intern("rx_frame"), pmt.to_pmt(msg_dict))
                              )
              except Exception as e:
                  print(f"Error in handle_phy_in: {e}")
          
          def handle_rx_ack(self, ack_src_mac):
              """
              Traitement quand on reçoit un ACK
              """
              if self.state == "WAIT_ACK":
                  # Extract destination MAC from the current frame (bytes 6-12 in the frame)
                  _, dst_mac, _, _ = parse_frame(self.current_frame)
                  
                  # Verify ACK came from the intended recipient
                  if ack_src_mac == dst_mac:
                      self.state = "IDLE"
                      self.current_frame = None
                      # Notifier le succès
                      self.message_port_pub(
                          pmt.intern("app_out"),
                          pmt.cons(pmt.intern("tx_success"), pmt.PMT_NIL)
                      )
                  else:
                      # If ACK came from wrong source, treat it as no ACK received
                      print(f"Received ACK from unexpected source: {ack_src_mac}")
                      self.retries += 1
                      if self.retries < self.max_retries:
                          self.cw = min(self.cw * 2, self.cw_max)
                          self.state = "BACKOFF"
                          self.start_backoff()
                      else:
                          self.state = "IDLE"
                          self.current_frame = None
                          # Notifier l'échec
                          self.message_port_pub(
                              pmt.intern("app_out"),
                              pmt.cons(pmt.intern("tx_failed"), pmt.PMT_NIL)
                          )
                          # Traiter le paquet suivant dans la file
                          self.process_next_packet()
          
          def handle_cs_in(self, msg_pmt):
              """
              Gestion du Carrier Sense
              """
              if pmt.is_bool(msg_pmt):
                  self.channel_busy = pmt.to_bool(msg_pmt)
          
          def general_work(self, clk):
              """
              Méthode appelée régulièrement par le scheduler de GNU Radio
              """
              now = time.time()
              dt = now - self.last_time
              self.last_time = now
              
              if self.state == "BACKOFF":
                  if not self.channel_busy:
                      self.backoff_remaining -= dt
                      if self.backoff_remaining <= 0:
                          self.state = "TX"
                          self.tx_frame()
              
              elif self.state == "WAIT_ACK":
                  if (now - self.wait_ack_start_time) > self.ack_timeout:
                      self.retries += 1
                      if self.retries < self.max_retries:
                          self.cw = min(self.cw * 2, self.cw_max)
                          self.state = "BACKOFF"
                          self.start_backoff()
                      else:
                          self.state = "IDLE"
                          self.current_frame = None
                          # Notifier l'échec
                          self.message_port_pub(
                              pmt.intern("app_out"),
                              pmt.cons(pmt.intern("tx_failed"), pmt.PMT_NIL)
                          )
                          # Traiter le paquet suivant dans la file
                          self.process_next_packet()
              
              return 0

          def process_next_packet(self):
              """
              Traite le prochain paquet dans la file d'attente
              """
              if not self.tx_queue.empty() and self.state == "IDLE":
                  frame, priority = self.tx_queue.get()
                  self.handle_new_frame(frame, priority)

          def stop(self):
              """
              Optionnel : si vous avez besoin de nettoyer des ressources à l'arrêt du flowgraph.
              """
              return super().stop()

      print("fichier présent")
    ack_timeout: '0.5'
    cw_max: '64'
    cw_min_high: '4'
    cw_min_low: '8'
    mac_addr: '34'
    max_retries: '2'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      from gnuradio import gr
      import numpy as np

      class float_to_bool_msg(gr.basic_block):
          """
          Convertit un flux float32 (0 ou 1) en messages booléens (False ou True).
          """
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="float_to_bool_msg",
                  in_sig=[np.float32],  # un canal d'entrée float32
                  out_sig=[]                  # pas de flux de sortie
              )
              
              # On déclare un port de sortie de message
              self.message_port_register_out(pmt.intern("state_out"))

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              n = len(in0)
              
              # Pour chaque échantillon, on envoie un message
              for val in in0:
                  if val >= 0.5:  # ou > 0.0 selon votre logique
                      msg = pmt.from_bool(False)
                  else:
                      msg = pmt.from_bool(True)
                  
                  # Publier le message
                  self.message_port_pub(pmt.intern("state_out"), msg)
              
              # Consommer tous les échantillons
              self.consume(0, n)
              
              return 0
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python3
      import time
      import random
      import pmt
      from gnuradio import gr
      import numpy as np
      import json

      class app_simulator(gr.basic_block):
          """
          Simulateur de la couche application qui envoie des données toutes les 30 secondes.
          Les données sont envoyées au format attendu par le bloc CSMA/CA.
          """
          def __init__(self, 
                       interval=30.0,  # Intervalle entre les envois en secondes
                       dst_mac=b'\xFF\xFF\xFF\xFF\xFF\xFF',  # Broadcast par défaut
                       min_size=10,    # Taille minimum des données en octets
                       max_size=100):  # Taille maximum des données en octets
              gr.basic_block.__init__(
                  self,
                  name="app_simulator",
                  in_sig=None,
                  out_sig=None
              )
              
              self.interval = interval
              self.dst_mac = dst_mac
              self.min_size = min_size
              self.max_size = max_size
              
              # Pour le timing
              self.last_tx = time.time()

              # Pour la clock de work
              self.message_port_register_in(pmt.intern("clock"))
              self.set_msg_handler(pmt.intern("clock"), self.general_work)
              
              # Port de sortie vers la couche MAC
              self.message_port_register_out(pmt.intern("app_out"))
              
              # Port optionnel pour recevoir les acquittements
              self.message_port_register_in(pmt.intern("app_in"))
              self.set_msg_handler(pmt.intern("app_in"), self.handle_mac_feedback)
          
          def handle_mac_feedback(self, msg_pmt):
              """
              Traite les retours de la couche MAC (succès/échec des transmissions)
              """
              if pmt.is_pair(msg_pmt):
                  key = pmt.symbol_to_string(pmt.car(msg_pmt))
                  if key == "tx_success":
                      print("[APP] Transmission réussie")
                  elif key == "tx_failed":
                      print("[APP] Échec de la transmission")
                  elif key == "rx_frame":
                      # Données reçues d'un autre nœud
                      data_dict = pmt.to_python(pmt.cdr(msg_pmt))
                      print(f"[APP] Données reçues de {data_dict['src_mac']}: {data_dict['data']}")
          
          def generate_random_data(self):
              """
              Génère des données aléatoires de taille variable
              """
              size = random.randint(self.min_size, self.max_size)
              # Simuler des données de capteur (température, humidité, etc.)
              temp = round(random.uniform(15, 30), 2)
              humidity = round(random.uniform(30, 80), 2)
              data = f"T{temp},H{humidity}" #.encode('utf-8')
              return data
          
          def general_work(self, clk):
              """
              Méthode appelée régulièrement par le scheduler de GNU Radio
              """
              now = time.time()
              
              # Vérifier si c'est le moment d'envoyer
              if (now - self.last_tx) >= self.interval:
                  # Générer des données
                  data = self.generate_random_data()
                  
                  # Créer le message pour la couche MAC
                  msg_dict = {
                      "dst_mac": self.dst_mac,
                      "priority": random.randint(0, 1),  # Priorité aléatoire
                      "data": data
                  }
                  msg_str = json.dumps(msg_dict)
                  
                  # Convertir en PMT et envoyer
                  try:
                      self.message_port_pub(
                          pmt.intern("app_out"),
                          pmt.cons(pmt.PMT_NIL, pmt.to_pmt(msg_str))
                      )
                      #print(f"[APP] Envoi de données: {data}")
                  except Exception as e:
                      print(f"[APP] Erreur lors de l'envoi: {e}")
                  
                  self.last_tx = now
              
              return 0

      print("fichier simu présent")
    dst_mac: '45'
    interval: '5'
    max_size: '100'
    min_size: '10'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import numpy as np


      class pmt_to_ichar(gr.sync_block):
          """
          Bloc GNU Radio pour transformer un message PMT en un flux d'entiers (int8)
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="PMT to Ichar",
                  in_sig=[],
                  out_sig=[np.int8],
              )
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              self.data_queue = bytearray()

          def handle_msg(self, msg_pmt):
              try:
                  # Vérifier si le message PMT contient une chaîne
                  if pmt.is_pair(msg_pmt):
                      msg_str = pmt.to_python(pmt.cdr(msg_pmt))
                      if isinstance(msg_str, str):
                          self.data_queue.extend(msg_str.encode("utf-8"))
              except Exception as e:
                  print(f"Erreur dans handle_msg : {e}")

          def work(self, input_items, output_items):
              out = output_items[0]
              length = min(len(out), len(self.data_queue))
              out[:length] = np.frombuffer(self.data_queue[:length], dtype=np.int8)
              self.data_queue = self.data_queue[length:]
              return length
  states: {}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import numpy as np
      import json


      class ichar_to_pmt(gr.sync_block):
          """
          Bloc GNU Radio pour transformer un flux d'entiers (int8) en un message PMT
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Ichar to PMT",
                  in_sig=[np.int8],
                  out_sig=[],
              )
              self.message_port_register_out(pmt.intern("out"))
              self.data_buffer = bytearray()

          def work(self, input_items, output_items):
              in_data = input_items[0]

              # Ajouter les données au tampon
              self.data_buffer.extend(in_data)

              # Décoder les données si disponibles
              try:
                  decoded_data = self.data_buffer.decode("utf-8", errors="ignore")
                  # Créer un dictionnaire JSON
                  message_dict = {"frame": {"dst_mac": 45, "priority": 1, "data": decoded_data}}
                  json_message = json.dumps(message_dict)

                  # Envoyer le message sous forme de PMT
                  msg_pmt = pmt.intern(json_message)
                  self.message_port_pub(pmt.intern("out"), msg_pmt)

                  # Réinitialiser le tampon
                  self.data_buffer = bytearray()
              except Exception as e:
                  print(f"Erreur lors du décodage ou de l'envoi : {e}")

              return len(in_data)
  states: {}
- name: epy_block_5_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import numpy as np
      import json


      class ichar_to_pmt(gr.sync_block):
          """
          Bloc GNU Radio pour transformer un flux d'entiers (int8) en un message PMT
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Ichar to PMT",
                  in_sig=[np.int8],
                  out_sig=[],
              )
              self.message_port_register_out(pmt.intern("out"))
              self.data_buffer = bytearray()

          def work(self, input_items, output_items):
              in_data = input_items[0]

              # Ajouter les données au tampon
              self.data_buffer.extend(in_data)

              # Décoder les données si disponibles
              try:
                  decoded_data = self.data_buffer.decode("utf-8", errors="ignore")
                  # Créer un dictionnaire JSON
                  message_dict = {"frame": {"dst_mac": 45, "priority": 1, "data": decoded_data}}
                  json_message = json.dumps(message_dict)

                  # Envoyer le message sous forme de PMT
                  msg_pmt = pmt.intern(json_message)
                  self.message_port_pub(pmt.intern("out"), msg_pmt)

                  # Réinitialiser le tampon
                  self.data_buffer = bytearray()
              except Exception as e:
                  print(f"Erreur lors du décodage ou de l'envoi : {e}")

              return len(in_data)
  states: {}
- name: epy_block_5_0_1
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import numpy as np
      import json


      class ichar_to_pmt(gr.sync_block):
          """
          Bloc GNU Radio pour transformer un flux d'entiers (int8) en un message PMT
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Ichar to PMT",
                  in_sig=[np.int8],
                  out_sig=[],
              )
              self.message_port_register_out(pmt.intern("out"))
              self.data_buffer = bytearray()

          def work(self, input_items, output_items):
              in_data = input_items[0]

              # Ajouter les données au tampon
              self.data_buffer.extend(in_data)

              # Décoder les données si disponibles
              try:
                  decoded_data = self.data_buffer.decode("utf-8", errors="ignore")
                  # Créer un dictionnaire JSON
                  message_dict = {"frame": {"dst_mac": 45, "priority": 1, "data": decoded_data}}
                  json_message = json.dumps(message_dict)

                  # Envoyer le message sous forme de PMT
                  msg_pmt = pmt.intern(json_message)
                  self.message_port_pub(pmt.intern("out"), msg_pmt)

                  # Réinitialiser le tampon
                  self.data_buffer = bytearray()
              except Exception as e:
                  print(f"Erreur lors du décodage ou de l'envoi : {e}")

              return len(in_data)
  states: {}

connections:
- [analog_random_uniform_source_x_0_0, '0', blocks_unpacked_to_packed_xx_0_0_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_1, clock]
- [blocks_message_strobe_0, strobe, epy_block_3, clock]
- [blocks_multiply_const_vxx_0_0_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_constellation_modulator_0_0_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', epy_block_5_0_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', epy_block_5_0_1, '0']
- [blocks_unpacked_to_packed_xx_0_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0_0_0_0, '0', blocks_throttle2_0_0, '0']
- [epy_block_0, '0', epy_block_2, '0']
- [epy_block_1, app_out, epy_block_3, app_in]
- [epy_block_1, phy_out, blocks_message_debug_0_0_0, print]
- [epy_block_1, phy_out, epy_block_4, in]
- [epy_block_2, state_out, epy_block_1, cs_in]
- [epy_block_3, app_out, epy_block_1, app_in]
- [epy_block_4, '0', blocks_packed_to_unpacked_xx_0, '0']
- [epy_block_4, '0', epy_block_5_0, '0']
- [epy_block_5_0, out, blocks_message_debug_0_0_0, print]
- [epy_block_5_0_0, out, blocks_message_debug_0_0_0, print]
- [epy_block_5_0_1, out, blocks_message_debug_0_0_0_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
